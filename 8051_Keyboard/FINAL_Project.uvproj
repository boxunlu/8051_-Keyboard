# Keil uVision project FINAL_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E52B Winbond
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: FINAL_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Text1.c
